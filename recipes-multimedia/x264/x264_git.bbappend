FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

TARGET_CFLAGS_append = " -fPIC -DPIC "

